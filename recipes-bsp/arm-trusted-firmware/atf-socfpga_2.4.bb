require arm-trusted-firmware.inc

ATF_VERSION = "v2.4.0"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "76b4d6ac9f1ca33e1969c29fd4fefbac737a082d"
