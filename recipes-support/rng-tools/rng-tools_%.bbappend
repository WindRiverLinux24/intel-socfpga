RNG-TOOLS_INC_WRLINUX = ""
RNG-TOOLS_INC_WRLINUX_osv-wrlinux = "rng-tools_wrlinux.inc"
require ${RNG-TOOLS_INC_WRLINUX}
