require linux-yocto-intel-socfpga.inc

KBRANCH:intel-socfpga-64 = "v6.6/standard/preempt-rt/intel-sdk-6.6/intel-socfpga"
