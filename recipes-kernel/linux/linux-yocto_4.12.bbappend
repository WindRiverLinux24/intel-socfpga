include linux-windriver-intel-socfpga.inc

KBRANCH_intel-socfpga-64b = "standard/wr-base"
