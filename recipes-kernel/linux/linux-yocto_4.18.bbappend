include linux-windriver-intel-socfpga.inc

KBRANCH_intel-socfpga-64 = "v4.18/standard/intel-socfpga"
