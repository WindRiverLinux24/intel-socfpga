require linux-yocto-intel-socfpga.inc

KBRANCH:intel-socfpga-64 = "v6.1/standard/preempt-rt/intel-sdk-6.1/intel-socfpga"
