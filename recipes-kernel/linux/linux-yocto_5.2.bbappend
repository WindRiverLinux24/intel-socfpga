require linux-yocto-intel-socfpga.inc

KBRANCH_intel-socfpga-64 = "v5.2/standard/intel-socfpga"

LINUX_VERSION_intel-socfpga-64 ?= "5.2.x"
