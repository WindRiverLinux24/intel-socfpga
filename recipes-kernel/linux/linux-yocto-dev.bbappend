include linux-windriver-intel-socfpga.inc

KBRANCH_intel-socfpga-64 = "standard/intel-socfpga"
