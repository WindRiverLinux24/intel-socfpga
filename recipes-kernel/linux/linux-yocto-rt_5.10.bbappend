require linux-yocto-intel-socfpga.inc

KBRANCH_intel-socfpga-64 = "v5.10/standard/preempt-rt/intel-sdk-5.10/intel-socfpga"
