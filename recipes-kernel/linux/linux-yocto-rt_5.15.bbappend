require linux-yocto-intel-socfpga.inc

KBRANCH:intel-socfpga-64 = "v5.15/standard/preempt-rt/intel-sdk-5.15/intel-socfpga"
